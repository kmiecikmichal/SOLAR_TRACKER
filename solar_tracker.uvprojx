# Keil uVision project solar_tracker.uvprojx, settings and files
target CMSIS-DAP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.3.0
  cpu: IRAM(0x1FFFFC00,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: solar_tracker
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: main.c uart.c i2c.c mma8451.c pwm.c extra.c adc.c mode1.c mode2.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
